# Keil uVision project STM32F103C8T6_demo.uvprojx, settings and files
target STM32F103C8T6_demo (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: apq-eio +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC
  c include: ../Core/Inc;     ../Core/Drivers/STM32F1xx_HAL_Driver/Inc;          ../Core/Drivers/CMSIS/Device/ST/STM32F1xx/Include;           ../Core/Drivers/CMSIS/Include;           ..\Middlewares\modbus\include;           ..\Middlewares\modbus\rtu;           ..\Middlewares\modbus\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ../Core/Src/: startup_stm32f105xc.s
  group Application/User/Core
    ../Core/Src/: spi.c uart.c AD717X.c adc_4112.c gpio.c dma.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c app.c AD5422.c clock.c flashapp.c
    ../Core/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c
    ../Core/Inc/: flashapp.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Core/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.4.0
